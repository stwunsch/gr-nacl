options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: public_key
  id: variable
  parameters:
    value: '"public.key"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: secret_key
  id: variable
  parameters:
    value: '"secret.key"'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.list1(pmt.list2(pmt.string_to_symbol("msg_clear"),pmt.init_u8vector(4,[116,101,115,116])))
    period: '1000'
  states: {}
- name: nacl_decrypt_public_0
  id: nacl_decrypt_public
  parameters:
    filename_pk: public.alice
    filename_sk: secret.bob
  states: {}
- name: nacl_encrypt_public_0
  id: nacl_encrypt_public
  parameters:
    Filename public-key (receiver): public_key
    Filename secret-key (sender): secret_key
  states: {}
- name: nacl_generate_keypair_0
  id: nacl_generate_keypair
  parameters:
    Filename public-key: public_key
    Filename secret-key: secret_key
  states: {}
- name: nacl_generate_keypair_0_0
  id: nacl_generate_keypair
  parameters:
    Filename public-key: public_key
    Filename secret-key: secret_key
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_message_debug_0_0, print]
- [blocks_message_strobe_0, strobe, nacl_encrypt_public_0, Msg clear]
- [nacl_decrypt_public_0, Msg decrypted, blocks_message_debug_0, print]
- [nacl_encrypt_public_0, Msg encrypted, blocks_message_debug_0_0_0, print]
- [nacl_encrypt_public_0, Msg encrypted, nacl_decrypt_public_0, Msg encrypted]

metadata:
  file_format: 1
