options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: public_key_r
  id: variable
  parameters:
    value: '"public.receiver"'
  states: {}
- name: public_key_s
  id: variable
  parameters:
    value: '"public.sender"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: secret_key_r
  id: variable
  parameters:
    value: '"secret.receiver"'
  states: {}
- name: secret_key_s
  id: variable
  parameters:
    value: '"secret.sender"'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.string_to_symbol("msg_clear")
    period: '1000'
  states: {}
- name: nacl_decrypt_public_0
  id: nacl_decrypt_public
  parameters:
    filename_pk: public_key_s
    filename_sk: secret_key_r
  states: {}
- name: nacl_encrypt_public_0
  id: nacl_encrypt_public
  parameters:
    filename_pk: public_key_r
    filename_sk: secret_key_s
  states: {}
- name: nacl_generate_keypair_0
  id: nacl_generate_keypair
  parameters:
    filename_pk: public_key_s
    filename_sk: secret_key_s
  states: {}
- name: nacl_generate_keypair_0_0
  id: nacl_generate_keypair
  parameters:
    filename_pk: public_key_r
    filename_sk: secret_key_r
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_message_debug_0_0, print]
- [blocks_message_strobe_0, strobe, nacl_encrypt_public_0, Msg clear]
- [nacl_decrypt_public_0, Msg decrypted, blocks_message_debug_0, print]
- [nacl_encrypt_public_0, Msg encrypted, blocks_message_debug_0_0_0, print]
- [nacl_encrypt_public_0, Msg encrypted, nacl_decrypt_public_0, Msg encrypted]

metadata:
  file_format: 1
