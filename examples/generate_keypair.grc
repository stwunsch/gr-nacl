<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>nacl_generate_keypair</key>
<param><key>id</key><value>nacl_generate_keypair_0</value></param>
<param><key>filename_sk</key><value>"secret.alice"</value></param>
<param><key>filename_pk</key><value>"public.alice"</value></param>
</block>
<block>
<key>nacl_generate_keypair</key>
<param><key>id</key><value>nacl_generate_keypair_0_0</value></param>
<param><key>filename_sk</key><value>"secret.bob"</value></param>
<param><key>filename_pk</key><value>"public.bob"</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.list1(pmt.list2(pmt.string_to_symbol("msg_clear"),pmt.init_u8vector(4,[116,101,115,116])))</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>nacl_decrypt_public</key>
<param><key>id</key><value>nacl_decrypt_public_0</value></param>
<param><key>filename_pk</key><value>public.alice</value></param>
<param><key>filename_sk</key><value>secret.bob</value></param>
</block>
<block>
<key>nacl_encrypt_public</key>
<param><key>id</key><value>nacl_encrypt_public_0</value></param>
<param><key>filename_pk</key><value>public.bob</value></param>
<param><key>filename_sk</key><value>secret.alice</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<connection><source_block_id>nacl_encrypt_public_0</source_block_id><sink_block_id>nacl_decrypt_public_0</sink_block_id><source_key>Msg encrypted</source_key><sink_key>Msg encrypted</sink_key></connection>
<connection><source_block_id>nacl_decrypt_public_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>Msg decrypted</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>nacl_encrypt_public_0</sink_block_id><source_key>strobe</source_key><sink_key>Msg clear</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>strobe</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>nacl_encrypt_public_0</source_block_id><sink_block_id>blocks_message_debug_0_0_0</sink_block_id><source_key>Msg encrypted</source_key><sink_key>print</sink_key></connection>
</flow_graph>
