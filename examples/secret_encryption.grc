options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.string_to_symbol("msg_clear")
    period: '1000'
  states: {}
- name: nacl_decrypt_secret_0
  id: nacl_decrypt_secret
  parameters:
    filename_key: '"secret.key"'
  states: {}
- name: nacl_encrypt_secret_0
  id: nacl_encrypt_secret
  parameters:
    filename_key: '"secret.key"'
  states: {}
- name: nacl_generate_key_0
  id: nacl_generate_key
  parameters:
    filename_key: '"secret.key"'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_message_debug_0_0, print]
- [blocks_message_strobe_0, strobe, nacl_encrypt_secret_0, Msg clear]
- [nacl_decrypt_secret_0, Msg decrypted, blocks_message_debug_0, print]
- [nacl_encrypt_secret_0, Msg encrypted, blocks_message_debug_0_0_0, print]
- [nacl_encrypt_secret_0, Msg encrypted, nacl_decrypt_secret_0, Msg encrypted]

metadata:
  file_format: 1
